IMAGE_INSTALL:append = " sdbus-lite"